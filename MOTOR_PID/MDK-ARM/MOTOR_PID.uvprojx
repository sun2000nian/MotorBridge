# Keil uVision project MOTOR_PID.uvprojx, settings and files
target MOTOR_PID (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MOTOR_PID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc;            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;            ../Drivers/CMSIS/Include;            ..\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32f4xx_hal_msp.cpp stm32f4xx_it.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MOTOR
    ../MOTOR/: motor.cpp PWM.cpp PID.cpp
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
